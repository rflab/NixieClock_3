# Repository rflab/NixieClock_3

File README.md:

nixie_clock_3
=============

ソースコードと回路図、Atmel AVR ATMEGA328使用
回路バグやソフトが未完成などは残ってます。

## KiCad design files/circuit/kicad/kicad_project.kicad_pcb

Parts:
C1, C2: 0.1u
C3: 10u
C4, C5: 22p
D1: DIODE
IC1: ATMEGA328-A; TQFP32
P1: CONN_6
R1: 510
R2: 1k
R3, R4, R5: 10k
U12, U13: MY_PIN72
U15, U16, U17, U18: MY_PIN52
X1: 12MHz

Connections:
170V: U17.5; also elsewhere on the board
+5V: U13.8, U16.1; also elsewhere on the board
+9V: U16.4; also elsewhere on the board
/INT0_D+: IC1.32 ((PCINT18/INT0)PD2), U12.1
/INT1_D-: IC1.1 ((PCINT19/OC2B/INT1)PD3), U12.14
/MISO: IC1.16 ((PCINT4/MISO)PB4), P1.5, U12.10
/MOSI: IC1.15 ((PCINT3/OC2A/MOSI)PB3), P1.6, U12.5
/PB0: IC1.12 ((PCINT0/CLKO/ICP1)PB0), U12.6
/PB1: IC1.13 ((PCINT1/OC1A)PB1), U12.7
/PB2: IC1.14 ((PCINT2/OC1B/~SS~)PB2), U12.9
/PC0: IC1.23 ((PCINT8/ADC0)PC0), U12.11
/PC1: IC1.24 ((PCINT9/ADC1)PC1), U12.3
/PC2: IC1.25 ((PCINT10/ADC2)PC2), U12.12
/PC3: IC1.26 ((PCINT11/ADC3)PC3), U12.4
/PINPB0: U13.6; also elsewhere on the board
/PINPB1: U13.7; also elsewhere on the board
/PINPB2: U13.9; also elsewhere on the board
/PINPB3: U13.5; also elsewhere on the board
/PINPB4: U13.10; also elsewhere on the board
/PINPC0: U13.12; also elsewhere on the board
/PINPC1: U13.3; also elsewhere on the board
/PINPC2: U13.11; also elsewhere on the board
/PINPC3: U13.4; also elsewhere on the board
/RESET: IC1.29 ((PCINT14/~RESET~)PC6), P1.2, R2.1
/SCK: IC1.17 ((PCINT5/SCK)PB5), P1.4
/Sheet53F8BA4D/out: IC1.19 (ADC6); also elsewhere on the board
/Sheet53F8FD69/A: IC1.11 ((PCINT23/AIN1)PD7); also elsewhere on the board
/Sheet53F8FD69/B: IC1.10 ((PCINT22/OC0A/AIN0)PD6); also elsewhere on the board
/Sheet53F8FD69/Push: IC1.9 ((PCINT21/OC0B/T1)PD5); also elsewhere on the board
/Sheet53F905A8/CLKOUT: IC1.2 ((PCINT20/XCK/T0)PD4); also elsewhere on the board
/Sheet53F905A8/SCL: IC1.28 ((PCINT14/SCL/ADC5)PC5), R4.2; also elsewhere on the board
/Sheet53F905A8/SDA: IC1.27 ((PCINT12/SDA/ADC4)PC4), R5.2; also elsewhere on the board
GND: U13.2, U13.13, U16.2, U16.3, U16.5, U16.6, U16.7, U16.8, U16.9, U16.10, U18.1, U18.2, U18.3, U18.4, U18.6, U18.7, U18.8, U18.9, U18.10; also elsewhere on the board
unnamed: C1.1, IC1.20 (AREF), R1.2
unnamed: C3.1, D1.1 (A), R2.2, R3.2
unnamed: C4.1, IC1.8 ((PCINT7/XTAL2/TOSC2)PB7), X1.1
unnamed: C5.1, IC1.7 ((PCINT6/XTAL1/TOSC1)PB6), X1.2
PIN5V: C2.1, D1.2 (K), IC1.4 (VCC), IC1.6 (VCC), IC1.18 (AVCC), P1.3, R1.1, R3.1, R4.1, R5.1, U12.8, U15.1; also elsewhere on the board
PIN9V: U15.4; also elsewhere on the board
PIN170V: U18.5; also elsewhere on the board
PIND+: U13.1; also elsewhere on the board
PIND-: U13.14; also elsewhere on the board
PINGND: C1.2, C2.2, C3.2, C4.2, C5.2, IC1.3 (GND), IC1.5 (GND), IC1.21 (GND), P1.1, U12.2, U12.13, U15.2, U15.3, U15.5, U15.6, U15.7, U15.8, U15.9, U15.10, U17.1, U17.2, U17.3, U17.4, U17.6, U17.7, U17.8, U17.9, U17.10; also elsewhere on the board

Notes on the sheet:
ISP tool (In system programmer)
Reset circuit startup in 0.1[sec]
9V in - 170V out, 5V out
upper board
lower board
IIC
USB

Parts:
C6, C15: 0.1u
IC2: 74LC138
IC3, IC4: TLP627
IC5: SN74141_K155NA
IC6, IC7: TLP627-4
R6: 330
R7, R8: 10k
R9, R10: 500k

Connections:
+5V: C6.2, C15.1, IC2.6, IC2.16, IC5.5, R6.1, R7.1; also elsewhere on the board
/PINPB0: IC2.1; also elsewhere on the board
/PINPB1: IC2.2; also elsewhere on the board
/PINPB2: IC2.3; also elsewhere on the board
/PINPB3: IC3.2; also elsewhere on the board
/PINPB4: IC4.2; also elsewhere on the board
/PINPC0: IC5.7; also elsewhere on the board
/PINPC1: IC5.6; also elsewhere on the board
/PINPC2: IC5.4; also elsewhere on the board
/PINPC3: IC5.3; also elsewhere on the board
/nixie/L1: IC2.15, IC6.2
/nixie/L2: IC2.14, IC6.4
/nixie/L3: IC2.13, IC6.6
/nixie/L4: IC2.12, IC6.8
/nixie/L5: IC2.11, IC7.2
/nixie/L6: IC2.10, IC7.4
/nixie/L7: IC2.9, IC7.6
/nixie/L8: IC2.7, IC7.8
/nixie/N0: IC5.2; also elsewhere on the board
/nixie/N1: IC5.1; also elsewhere on the board
/nixie/N2: IC5.15; also elsewhere on the board
/nixie/N3: IC5.16; also elsewhere on the board
/nixie/N4: IC5.13; also elsewhere on the board
/nixie/N5: IC5.14; also elsewhere on the board
/nixie/N6: IC5.9; also elsewhere on the board
/nixie/N7: IC5.10; also elsewhere on the board
/nixie/N8: IC5.11; also elsewhere on the board
/nixie/N9: IC5.8; also elsewhere on the board
/nixie/Sheet53F9F7BA/1: IC6.15; also elsewhere on the board
/nixie/Sheet53F9F7BA/2: IC6.13; also elsewhere on the board
/nixie/Sheet53F9F7BA/3: IC6.9; also elsewhere on the board
/nixie/Sheet53F9F7BA/4: IC7.15; also elsewhere on the board
/nixie/Sheet53F9F7BA/5: IC7.11; also elsewhere on the board
/nixie/Sheet53F9F7BA/6: IC7.9; also elsewhere on the board
/nixie/Sheet53F9F7BA/colon_l: IC6.11; also elsewhere on the board
/nixie/Sheet53F9F7BA/colon_r: IC7.13; also elsewhere on the board
/nixie/Sheet53F9F7BA/dot_cathode_l: IC3.4; also elsewhere on the board
/nixie/Sheet53F9F7BA/dot_cathode_r: IC4.4; also elsewhere on the board
GND: C6.1, C15.2, IC2.4, IC2.5, IC2.8, IC5.12, R9.2, R10.2; also elsewhere on the board
unnamed: IC3.3, R10.1
unnamed: IC4.3, R9.1
unnamed: IC3.1, IC4.1, R6.2
unnamed: IC6.10, IC6.12, IC6.14, IC6.16, IC7.10, IC7.12, IC7.14, IC7.16, R8.2
unnamed: IC6.1, IC6.3, IC6.5, IC6.7, IC7.1, IC7.3, IC7.5, IC7.7, R7.2
PIN170V: R8.1; also elsewhere on the board

Notes on the sheet:
1: 8 2: 9 3: A 4: D 5: VCC 6: B 7: C 8: 2 9: 3 10: 7 11: 6 12: GND 13: 4 14: 5 15: 1 16: 0

Parts:
PD1: PHOTO_DIODE
R11: 10k

Connections:
/Sheet53F8BA4D/out: PD1.2 (K), R11.2; also elsewhere on the board
PIN5V: PD1.1 (A); also elsewhere on the board
PINGND: R11.1; also elsewhere on the board

Parts:
C7, C11: 25V 10u
C8, C9, C10: 0.1u
C12: 1000p
C13: 350V 1u
D2, D6, D7: DIODE
F1: FUSE
IC8: MY_3_TERMINAL_REGULATOR
IC9: ICM7555CD
IC10: MY_FET_P
IC12: MY_NPN
IC13: MY_PNP
IC14: MY_FET_N
L1: 220uH
R12, R13, R14, R19: 10k
R15: 10K
R16: 4.7k
R17, R18: 500k
R33: R
T1: 2SC
U11: DC_JACK
VR1: 100k
VR2: 10k

Connections:
170V: C13.1, D2.2 (K), R17.1; also elsewhere on the board
+5V: C11.1, D6.2 (K), D7.2 (K); also elsewhere on the board
+9V: F1.1, U11.1; also elsewhere on the board
GND: C7.2, C8.2, C9.2, C11.2, IC8.2, U11.3; also elsewhere on the board
unnamed: IC12.1 (B), IC13.1 (B), R14.2, R15.2
unnamed: C7.1, C8.1, F1.2, IC8.1
unnamed: R18.2, R19.1, T1.1 (B)
unnamed: R17.2, R18.1
unnamed: R19.2, VR2.1
unnamed: D6.1 (A), IC10.3
unnamed: C9.1, D7.1 (A), IC8.3, IC10.1
unnamed: D2.1 (A), IC14.3, L1.2
unnamed: R13.1, VR1.1
unnamed: IC9.7 (DIS), R12.1, R13.2
unnamed: C12.1, IC9.2 (~TRG), IC9.6 (THRE), VR1.2, VR1.3
unnamed: IC9.3 (OUT), R14.1
unnamed: IC9.5 (CTRL), T1.2 (C)
unnamed: IC12.3 (C), R16.2
unnamed: IC12.2 (E), IC13.2 (E), IC14.1, R15.1
unnamed: IC13.3 (C), R33.1
PIN9V: C10.2, IC9.4 (~RST), IC9.8 (VDD), L1.1, R12.2, R16.1; also elsewhere on the board
PINGND: C10.1, C12.2, C13.2, IC9.1 (GND), IC14.2, R33.2, T1.3 (E), VR2.2, VR2.3; also elsewhere on the board
USB5V: IC10.2; also elsewhere on the board

Parts:
CON1: USB_MINI_B
D3, D4: DIODE
R20, R21: 68
R22: 2K
R23: NC
R32: 1M

Connections:
+5V: R22.1; also elsewhere on the board
GND: CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), CON1.8 (SHELL3), CON1.9 (SHELL4), D3.1 (A), D4.1 (A), R23.1, R32.2; also elsewhere on the board
unnamed: CON1.4 (ID), R23.2
unnamed: CON1.3 (D+), D3.2 (K), R21.2, R32.1
unnamed: CON1.2 (D-), D4.2 (K), R20.2, R22.2
PIND+: R21.1; also elsewhere on the board
PIND-: R20.1; also elsewhere on the board
USB5V: CON1.1 (VBUS); also elsewhere on the board

Parts:
R24, R25, R26: 10k
SW3, SW4, SW5: SW_PUSH

Connections:
/Sheet53F8FD69/A: R24.2, SW3.1; also elsewhere on the board
/Sheet53F8FD69/B: R25.2, SW4.1; also elsewhere on the board
/Sheet53F8FD69/Push: R26.2, SW5.1; also elsewhere on the board
PIN5V: R24.1, R25.1, R26.1; also elsewhere on the board
PINGND: SW3.2, SW4.2, SW5.2; also elsewhere on the board

Notes on the sheet:
Push switch or ECQWK

Parts:
C14: 5.5V 0.1F
C18: 0.1u
D5: DIODE
IC11: DS1307
R27: 3.3k
R28: 7.5k
R29: 10k
X2: 32.768kHz

Connections:
/Sheet53F905A8/CLKOUT: IC11.7, R29.2; also elsewhere on the board
/Sheet53F905A8/SCL: IC11.6; also elsewhere on the board
/Sheet53F905A8/SDA: IC11.5; also elsewhere on the board
unnamed: C14.1, D5.2 (K), IC11.3
unnamed: D5.1 (A), R27.2, R28.1
unnamed: IC11.1, X2.2
unnamed: IC11.2, X2.1
PIN5V: C18.1, IC11.8, R27.1, R29.1; also elsewhere on the board
PINGND: C14.2, C18.2, IC11.4, R28.2; also elsewhere on the board

Parts:
K1, K2, K3, K4, K5: CONN_3
R30, R31: N/A
U1, U2, U3, U4, U14, U19: NEON
U5, U6, U7, U8, U9, U10: NIXIE_IN_16

Connections:
/nixie/N0: U5.2 (1), U6.2 (1), U7.2 (1), U8.2 (1), U9.2 (1), U10.2 (1); also elsewhere on the board
/nixie/N1: U5.3 (7), U6.3 (7), U7.3 (7), U8.3 (7), U9.3 (7), U10.3 (7); also elsewhere on the board
/nixie/N2: U5.4 (3), U6.4 (3), U7.4 (3), U8.4 (3), U9.4 (3), U10.4 (3); also elsewhere on the board
/nixie/N3: U5.6 (4), U6.6 (4), U7.6 (4), U8.6 (4), U9.6 (4), U10.6 (4); also elsewhere on the board
/nixie/N4: U5.7 (5), U6.7 (5), U7.7 (5), U8.7 (5), U9.7 (5), U10.7 (5); also elsewhere on the board
/nixie/N5: U5.8 (6), U6.8 (6), U7.8 (6), U8.8 (6), U9.8 (6), U10.8 (6); also elsewhere on the board
/nixie/N6: U5.9 (2), U6.9 (2), U7.9 (2), U8.9 (2), U9.9 (2), U10.9 (2); also elsewhere on the board
/nixie/N7: U5.11 (8), U6.11 (8), U7.11 (8), U8.11 (8), U9.11 (8), U10.11 (8); also elsewhere on the board
/nixie/N8: U5.12 (9), U6.12 (9), U7.12 (9), U8.12 (9), U9.12 (9), U10.12 (9); also elsewhere on the board
/nixie/N9: U5.13 (0), U6.13 (0), U7.13 (0), U8.13 (0), U9.13 (0), U10.13 (0); also elsewhere on the board
/nixie/Sheet53F9F7BA/1: U5.1 (plate); also elsewhere on the board
/nixie/Sheet53F9F7BA/2: U8.1 (plate); also elsewhere on the board
/nixie/Sheet53F9F7BA/3: U6.1 (plate); also elsewhere on the board
/nixie/Sheet53F9F7BA/4: U9.1 (plate); also elsewhere on the board
/nixie/Sheet53F9F7BA/5: U7.1 (plate); also elsewhere on the board
/nixie/Sheet53F9F7BA/6: U10.1 (plate); also elsewhere on the board
/nixie/Sheet53F9F7BA/NEG1: K2.1, U1.2, U2.2
/nixie/Sheet53F9F7BA/NEG2: K4.1, U3.2, U4.2
/nixie/Sheet53F9F7BA/NEG3: K5.1, U14.2, U19.2
/nixie/Sheet53F9F7BA/NEL1: K2.2 (PM), U1.1
/nixie/Sheet53F9F7BA/NEL2: K4.2 (PM), U3.1
/nixie/Sheet53F9F7BA/NEL3: K5.2 (PM), U14.1
/nixie/Sheet53F9F7BA/NEU1: K2.3, U2.1
/nixie/Sheet53F9F7BA/NEU2: K4.3, U4.1
/nixie/Sheet53F9F7BA/NEU3: K5.3, U19.1
/nixie/Sheet53F9F7BA/colon_l: K1.1, R30.1; also elsewhere on the board
/nixie/Sheet53F9F7BA/colon_r: K3.1, R31.1; also elsewhere on the board
/nixie/Sheet53F9F7BA/dot_cathode_l: K1.2 (PM), K3.2 (PM), U5.5 (comma), U6.5 (comma), U7.5 (comma), U8.5 (comma), U9.5 (comma), U10.5 (comma); also elsewhere on the board
/nixie/Sheet53F9F7BA/dot_cathode_r: K1.3, K3.3, U5.10 (comma), U6.10 (comma), U7.10 (comma), U8.10 (comma), U9.10 (comma), U10.10 (comma); also elsewhere on the board
GND: R30.2, R31.2; also elsewhere on the board

Board: 2 copper layers, 100.0 x 90.0 mm, 110 parts (30 on the bottom side), 109 nets.

Other parts of the board:
M3, M3#2, M3#3: my_M3_screw

## Commit log

2014-08-16 add source files
2014-08-16 move files
2014-08-17 support iic
2014-08-19 support ADC, change charactor code
2014-08-20 add pcb (kiCad project)
2014-08-23 回路更新
    マイコン周り作成、各子階層シートを追加
2014-08-23 回路図更新
    温度湿度センサ
    大気圧センサ
    輝度センサ
2014-08-24 回路図更新、DS1307対応
    バスの接続が未
2014-08-24 回路図出図
2014-08-26 回路図ERC途中
2014-08-26 回路図ERC完了
2014-08-27 部品リスト・パッケージライブラリを更新
2014-08-28 部品リスト完了、PCBに部品を配置
2014-08-28 readmeを追加
2014-08-30 PCB更新
2014-08-31 必要性の低い部品を削除
    機能てんこ盛りよりシンプル小型化のほうがいいかなと思ったので一気に部品を削除
2014-09-01 設計見直し
    部品見直し
    USB・DCジャック自動切り替え
    マイコンを下段のボードに移動
    ニキシー管駆動電源を上段ボードに移動
2014-09-02 PCB更新
    ニキシー管の足を接続
    電源仮接続
2014-09-04 回路図を出図
2014-09-05 基板が描けた
2014-09-06 DRC完了
    あとはシルク移動かなぁ
2014-09-06 ガーバー出力
2014-09-07 回路完成、ディレクトリ構造変更
2014-09-07 配線の太さを調整
2014-09-08 基板完成、発注版
2014-09-11 不要ファイルの削除
2014-10-03 ソースコード修正
    現状回路バグ未修正
2014-10-11 ケース用ファイル追加
2014-10-13 ケース底面最終盤
2014-10-17 時間設定機能を追加
2014-10-17 ケースのファイルを更新
2016-01-08 写真追加
